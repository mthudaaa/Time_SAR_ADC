v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 190 20 0 0 {name=p349 lab=clk }
C {devices/opin.sym} 270 20 0 0 {name=p350 lab=clk_comp }
C {devices/opin.sym} 270 40 0 0 {name=p351 lab=clk_comp_shifted }
C {devices/ipin.sym} 190 40 0 0 {name=p352 lab=en }
C {devices/opin.sym} 270 60 0 0 {name=p353 lab=samp }
C {devices/ipin.sym} 190 60 0 0 {name=p354 lab=vcn }
C {devices/ipin.sym} 190 80 0 0 {name=p355 lab=vcp }
C {devices/iopin.sym} 270 80 0 0 {name=p356 lab=VPWR }
C {devices/iopin.sym} 270 100 0 0 {name=p357 lab=VGND }
C {devices/opin.sym} 270 120 0 0 {name=p358 lab=dac_ctrl[7:0] }
C {devices/opin.sym} 270 140 0 0 {name=p359 lab=dout[7:0] }
C {devices/lab_pin.sym} 1260 30 0 0 {name=p0 lab=en }
C {devices/lab_pin.sym} 1340 30 0 1 {name=p1 lab=_041_ }
C {sky130_stdcells/inv_2.sym} 1300 30 0 0 {name=X_069_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 1260 150 0 0 {name=p2 lab=cmp__processor__0_dcomp }
C {devices/lab_pin.sym} 1340 150 0 1 {name=p3 lab=_042_ }
C {sky130_stdcells/inv_2.sym} 1300 150 0 0 {name=X_070_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 1260 270 0 0 {name=p4 lab=sar__logic__0_deoc }
C {devices/lab_pin.sym} 1340 270 0 1 {name=p5 lab=_043_ }
C {sky130_stdcells/inv_2.sym} 1300 270 0 0 {name=X_071_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 1260 390 0 0 {name=p6 lab=sar__logic__0_dcount_o1_c }
C {devices/lab_pin.sym} 1340 390 0 1 {name=p7 lab=_044_ }
C {sky130_stdcells/inv_2.sym} 1300 390 0 0 {name=X_072_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 1260 510 0 0 {name=p8 lab=sar__logic__0_dcount_o0_c }
C {devices/lab_pin.sym} 1340 510 0 1 {name=p9 lab=_045_ }
C {sky130_stdcells/inv_2.sym} 1300 510 0 0 {name=X_073_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 1260 630 0 0 {name=p10 lab=vcn }
C {devices/lab_pin.sym} 1340 630 0 1 {name=p11 lab=_046_ }
C {sky130_stdcells/inv_2.sym} 1300 630 0 0 {name=X_074_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 1260 750 0 0 {name=p12 lab=smp__clk__div__0_dstart }
C {devices/lab_pin.sym} 1340 750 0 1 {name=p13 lab=_047_ }
C {sky130_stdcells/inv_2.sym} 1300 750 0 0 {name=X_075_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 1260 870 0 0 {name=p14 lab=sar__logic__0_dcount_o2_c }
C {devices/lab_pin.sym} 1340 870 0 1 {name=p15 lab=_048_ }
C {sky130_stdcells/inv_2.sym} 1300 870 0 0 {name=X_076_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 1260 990 0 0 {name=p16 lab=clk }
C {devices/lab_pin.sym} 1340 990 0 1 {name=p17 lab=_029_ }
C {sky130_stdcells/inv_2.sym} 1300 990 0 0 {name=X_077_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 1240 1100 0 0 {name=p18 lab=en }
C {devices/lab_pin.sym} 1240 1140 0 0 {name=p19 lab=clk_comp }
C {devices/lab_pin.sym} 1360 1120 0 1 {name=p20 lab=_030_ }
C {sky130_stdcells/nand2_2.sym} 1300 1120 0 0 {name=X_078_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 1240 1240 0 0 {name=p21 lab=sar__logic__0_dcount_o1_c }
C {devices/lab_pin.sym} 1240 1280 0 0 {name=p22 lab=sar__logic__0_dcount_o0_c }
C {devices/lab_pin.sym} 1360 1260 0 1 {name=p23 lab=_049_ }
C {sky130_stdcells/nor2_2.sym} 1300 1260 0 0 {name=X_079_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 1240 1370 0 0 {name=p24 lab=sar__logic__0_dcount_o1_c }
C {devices/lab_pin.sym} 1240 1410 0 0 {name=p25 lab=sar__logic__0_dcount_o0_c }
C {devices/lab_pin.sym} 1240 1450 0 0 {name=p26 lab=sar__logic__0_dcount_o2_c }
C {devices/lab_pin.sym} 1360 1410 0 1 {name=p27 lab=_050_ }
C {sky130_stdcells/or3_2.sym} 1300 1410 0 0 {name=X_080_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 2160 20 0 0 {name=p28 lab=clk_comp }
C {devices/lab_pin.sym} 2160 60 0 0 {name=p29 lab=clk_comp_shifted }
C {devices/lab_pin.sym} 2280 40 0 1 {name=p30 lab=_000_ }
C {sky130_stdcells/and2b_2.sym} 2220 40 0 0 {name=X_081_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 2160 140 0 0 {name=p31 lab=sar__logic__0_deoc }
C {devices/lab_pin.sym} 2160 180 0 0 {name=p32 lab=clk_comp }
C {devices/lab_pin.sym} 2160 220 0 0 {name=p33 lab=smp__clk__div__0_dstart }
C {devices/lab_pin.sym} 2160 260 0 0 {name=p34 lab=clk_comp_shifted }
C {devices/lab_pin.sym} 2280 200 0 1 {name=p35 lab=_051_ }
C {sky130_stdcells/and4bb_2.sym} 2220 200 0 0 {name=X_082_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 2160 320 0 0 {name=p36 lab=sar__logic__0_deoc }
C {devices/lab_pin.sym} 2160 360 0 0 {name=p37 lab=clk_comp }
C {devices/lab_pin.sym} 2160 400 0 0 {name=p38 lab=smp__clk__div__0_dstart }
C {devices/lab_pin.sym} 2160 440 0 0 {name=p39 lab=clk_comp_shifted }
C {devices/lab_pin.sym} 2280 380 0 1 {name=p40 lab=_052_ }
C {sky130_stdcells/or4bb_2.sym} 2220 380 0 0 {name=X_083_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 2160 520 0 0 {name=p41 lab=cmp__processor__0_dcomp }
C {devices/lab_pin.sym} 2160 560 0 0 {name=p42 lab=_052_ }
C {devices/lab_pin.sym} 2280 540 0 1 {name=p43 lab=_053_ }
C {sky130_stdcells/nor2_2.sym} 2220 540 0 0 {name=X_084_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 2160 660 0 0 {name=p44 lab=sar__logic__0_deoc }
C {devices/lab_pin.sym} 2160 700 0 0 {name=p45 lab=clk_comp }
C {devices/lab_pin.sym} 2280 680 0 1 {name=p46 lab=_054_ }
C {sky130_stdcells/nand2b_2.sym} 2220 680 0 0 {name=X_085_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 2140 780 0 0 {name=p47 lab=sar__logic__0_deoc }
C {devices/lab_pin.sym} 2140 820 0 0 {name=p48 lab=dac_ctrl[0] }
C {devices/lab_pin.sym} 2140 860 0 0 {name=p49 lab=_050_ }
C {devices/lab_pin.sym} 2140 900 0 0 {name=p50 lab=_054_ }
C {devices/lab_pin.sym} 2300 840 0 1 {name=p51 lab=_055_ }
C {sky130_stdcells/o22a_2.sym} 2220 840 0 0 {name=X_086_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 2140 960 0 0 {name=p52 lab=_048_ }
C {devices/lab_pin.sym} 2140 1000 0 0 {name=p53 lab=_049_ }
C {devices/lab_pin.sym} 2140 1040 0 0 {name=p54 lab=_053_ }
C {devices/lab_pin.sym} 2140 1080 0 0 {name=p55 lab=_055_ }
C {devices/lab_pin.sym} 2300 1020 0 1 {name=p56 lab=_001_ }
C {sky130_stdcells/a31o_2.sym} 2220 1020 0 0 {name=X_087_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 2160 1160 0 0 {name=p57 lab=dac_ctrl[1] }
C {devices/lab_pin.sym} 2160 1200 0 0 {name=p58 lab=sar__logic__0_deoc }
C {devices/lab_pin.sym} 2280 1180 0 1 {name=p59 lab=_056_ }
C {sky130_stdcells/or2_2.sym} 2220 1180 0 0 {name=X_088_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 2160 1300 0 0 {name=p60 lab=sar__logic__0_dcount_o1_c }
C {devices/lab_pin.sym} 2160 1340 0 0 {name=p61 lab=sar__logic__0_dcount_o0_c }
C {devices/lab_pin.sym} 2280 1320 0 1 {name=p62 lab=_057_ }
C {sky130_stdcells/and2b_2.sym} 2220 1320 0 0 {name=X_089_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 2160 1430 0 0 {name=p63 lab=sar__logic__0_dcount_o2_c }
C {devices/lab_pin.sym} 2160 1470 0 0 {name=p64 lab=_054_ }
C {devices/lab_pin.sym} 2160 1510 0 0 {name=p65 lab=_057_ }
C {devices/lab_pin.sym} 2280 1470 0 1 {name=p66 lab=_058_ }
C {sky130_stdcells/or3b_2.sym} 2220 1470 0 0 {name=X_090_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 3060 -10 0 0 {name=p67 lab=_048_ }
C {devices/lab_pin.sym} 3060 30 0 0 {name=p68 lab=_053_ }
C {devices/lab_pin.sym} 3060 70 0 0 {name=p69 lab=_057_ }
C {devices/lab_pin.sym} 3060 110 0 0 {name=p70 lab=_058_ }
C {devices/lab_pin.sym} 3060 150 0 0 {name=p71 lab=_056_ }
C {devices/lab_pin.sym} 3220 70 0 1 {name=p72 lab=_002_ }
C {sky130_stdcells/a32o_2.sym} 3140 70 0 0 {name=X_091_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 3080 220 0 0 {name=p73 lab=sar__logic__0_deoc }
C {devices/lab_pin.sym} 3080 260 0 0 {name=p74 lab=dac_ctrl[2] }
C {devices/lab_pin.sym} 3200 240 0 1 {name=p75 lab=_059_ }
C {sky130_stdcells/or2_2.sym} 3140 240 0 0 {name=X_092_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 3060 330 0 0 {name=p76 lab=_044_ }
C {devices/lab_pin.sym} 3060 370 0 0 {name=p77 lab=sar__logic__0_dcount_o0_c }
C {devices/lab_pin.sym} 3060 410 0 0 {name=p78 lab=sar__logic__0_dcount_o2_c }
C {devices/lab_pin.sym} 3060 450 0 0 {name=p79 lab=_054_ }
C {devices/lab_pin.sym} 3060 490 0 0 {name=p80 lab=_059_ }
C {devices/lab_pin.sym} 3220 410 0 1 {name=p81 lab=_060_ }
C {sky130_stdcells/o41a_2.sym} 3140 410 0 0 {name=X_093_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 3080 540 0 0 {name=p82 lab=_042_ }
C {devices/lab_pin.sym} 3080 580 0 0 {name=p83 lab=sar__logic__0_dcount_o1_c }
C {devices/lab_pin.sym} 3080 620 0 0 {name=p84 lab=_045_ }
C {devices/lab_pin.sym} 3080 660 0 0 {name=p85 lab=_051_ }
C {devices/lab_pin.sym} 3200 600 0 1 {name=p86 lab=_061_ }
C {sky130_stdcells/and4_2.sym} 3140 600 0 0 {name=X_094_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 3060 710 0 0 {name=p87 lab=sar__logic__0_dcount_o1_c }
C {devices/lab_pin.sym} 3060 750 0 0 {name=p88 lab=_045_ }
C {devices/lab_pin.sym} 3060 790 0 0 {name=p89 lab=_048_ }
C {devices/lab_pin.sym} 3060 830 0 0 {name=p90 lab=_053_ }
C {devices/lab_pin.sym} 3060 860 0 0 {name=p91 lab=_060_ }
C {devices/lab_pin.sym} 3220 790 0 1 {name=p92 lab=_003_ }
C {sky130_stdcells/a41o_2.sym} 3140 790 0 0 {name=X_095_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 3080 940 0 0 {name=p93 lab=sar__logic__0_deoc }
C {devices/lab_pin.sym} 3080 980 0 0 {name=p94 lab=dac_ctrl[3] }
C {devices/lab_pin.sym} 3200 960 0 1 {name=p95 lab=_062_ }
C {sky130_stdcells/or2_2.sym} 3140 960 0 0 {name=X_096_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 3080 1080 0 0 {name=p96 lab=sar__logic__0_dcount_o1_c }
C {devices/lab_pin.sym} 3080 1120 0 0 {name=p97 lab=sar__logic__0_dcount_o0_c }
C {devices/lab_pin.sym} 3200 1100 0 1 {name=p98 lab=_063_ }
C {sky130_stdcells/nand2_2.sym} 3140 1100 0 0 {name=X_097_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 3060 1190 0 0 {name=p99 lab=_044_ }
C {devices/lab_pin.sym} 3060 1230 0 0 {name=p100 lab=_045_ }
C {devices/lab_pin.sym} 3060 1270 0 0 {name=p101 lab=sar__logic__0_dcount_o2_c }
C {devices/lab_pin.sym} 3060 1310 0 0 {name=p102 lab=_054_ }
C {devices/lab_pin.sym} 3060 1350 0 0 {name=p103 lab=_062_ }
C {devices/lab_pin.sym} 3220 1270 0 1 {name=p104 lab=_064_ }
C {sky130_stdcells/o41a_2.sym} 3140 1270 0 0 {name=X_098_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 3060 1390 0 0 {name=p105 lab=sar__logic__0_dcount_o1_c }
C {devices/lab_pin.sym} 3060 1430 0 0 {name=p106 lab=sar__logic__0_dcount_o0_c }
C {devices/lab_pin.sym} 3060 1470 0 0 {name=p107 lab=_048_ }
C {devices/lab_pin.sym} 3060 1510 0 0 {name=p108 lab=_053_ }
C {devices/lab_pin.sym} 3060 1540 0 0 {name=p109 lab=_064_ }
C {devices/lab_pin.sym} 3220 1470 0 1 {name=p110 lab=_004_ }
C {sky130_stdcells/a41o_2.sym} 3140 1470 0 0 {name=X_099_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 4000 20 0 0 {name=p111 lab=clk_comp }
C {devices/lab_pin.sym} 4000 60 0 0 {name=p112 lab=sar__logic__0_dcount_o2_c }
C {devices/lab_pin.sym} 4120 40 0 1 {name=p113 lab=_065_ }
C {sky130_stdcells/nand2_2.sym} 4060 40 0 0 {name=X_100_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 3980 140 0 0 {name=p114 lab=sar__logic__0_dcount_o1_c }
C {devices/lab_pin.sym} 3980 180 0 0 {name=p115 lab=sar__logic__0_dcount_o0_c }
C {devices/lab_pin.sym} 3980 220 0 0 {name=p116 lab=_065_ }
C {devices/lab_pin.sym} 3980 260 0 0 {name=p117 lab=dac_ctrl[4] }
C {devices/lab_pin.sym} 4140 200 0 1 {name=p118 lab=_066_ }
C {sky130_stdcells/o31a_2.sym} 4060 200 0 0 {name=X_101_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 3980 310 0 0 {name=p119 lab=sar__logic__0_dcount_o2_c }
C {devices/lab_pin.sym} 3980 350 0 0 {name=p120 lab=_049_ }
C {devices/lab_pin.sym} 3980 390 0 0 {name=p121 lab=_053_ }
C {devices/lab_pin.sym} 3980 430 0 0 {name=p122 lab=_066_ }
C {devices/lab_pin.sym} 3980 470 0 0 {name=p123 lab=sar__logic__0_deoc }
C {devices/lab_pin.sym} 4140 390 0 1 {name=p124 lab=_005_ }
C {sky130_stdcells/a311o_2.sym} 4060 390 0 0 {name=X_102_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 4000 540 0 0 {name=p125 lab=sar__logic__0_deoc }
C {devices/lab_pin.sym} 4000 580 0 0 {name=p126 lab=dac_ctrl[5] }
C {devices/lab_pin.sym} 4120 560 0 1 {name=p127 lab=_067_ }
C {sky130_stdcells/or2_2.sym} 4060 560 0 0 {name=X_103_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 3980 650 0 0 {name=p128 lab=sar__logic__0_dcount_o1_c }
C {devices/lab_pin.sym} 3980 690 0 0 {name=p129 lab=_045_ }
C {devices/lab_pin.sym} 3980 730 0 0 {name=p130 lab=_048_ }
C {devices/lab_pin.sym} 3980 770 0 0 {name=p131 lab=_054_ }
C {devices/lab_pin.sym} 3980 810 0 0 {name=p132 lab=_067_ }
C {devices/lab_pin.sym} 4140 730 0 1 {name=p133 lab=_068_ }
C {sky130_stdcells/o41a_2.sym} 4060 730 0 0 {name=X_104_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 3980 860 0 0 {name=p134 lab=sar__logic__0_dcount_o2_c }
C {devices/lab_pin.sym} 3980 900 0 0 {name=p135 lab=_053_ }
C {devices/lab_pin.sym} 3980 940 0 0 {name=p136 lab=_057_ }
C {devices/lab_pin.sym} 3980 980 0 0 {name=p137 lab=_068_ }
C {devices/lab_pin.sym} 4140 920 0 1 {name=p138 lab=_006_ }
C {sky130_stdcells/a31o_2.sym} 4060 920 0 0 {name=X_105_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 3980 1040 0 0 {name=p139 lab=_044_ }
C {devices/lab_pin.sym} 3980 1080 0 0 {name=p140 lab=sar__logic__0_dcount_o0_c }
C {devices/lab_pin.sym} 3980 1120 0 0 {name=p141 lab=_065_ }
C {devices/lab_pin.sym} 3980 1160 0 0 {name=p142 lab=dac_ctrl[6] }
C {devices/lab_pin.sym} 4140 1100 0 1 {name=p143 lab=_033_ }
C {sky130_stdcells/o31a_2.sym} 4060 1100 0 0 {name=X_106_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 3980 1220 0 0 {name=p144 lab=sar__logic__0_dcount_o2_c }
C {devices/lab_pin.sym} 3980 1260 0 0 {name=p145 lab=_061_ }
C {devices/lab_pin.sym} 3980 1300 0 0 {name=p146 lab=_033_ }
C {devices/lab_pin.sym} 3980 1340 0 0 {name=p147 lab=sar__logic__0_deoc }
C {devices/lab_pin.sym} 4140 1280 0 1 {name=p148 lab=_007_ }
C {sky130_stdcells/a211o_2.sym} 4060 1280 0 0 {name=X_107_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 4000 1410 0 0 {name=p149 lab=sar__logic__0_dcount_o1_c }
C {devices/lab_pin.sym} 4000 1450 0 0 {name=p150 lab=sar__logic__0_dcount_o0_c }
C {devices/lab_pin.sym} 4000 1490 0 0 {name=p151 lab=sar__logic__0_dcount_o2_c }
C {devices/lab_pin.sym} 4120 1450 0 1 {name=p152 lab=_034_ }
C {sky130_stdcells/and3_2.sym} 4060 1450 0 0 {name=X_108_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 4920 20 0 0 {name=p153 lab=_051_ }
C {devices/lab_pin.sym} 4920 60 0 0 {name=p154 lab=_034_ }
C {devices/lab_pin.sym} 5040 40 0 1 {name=p155 lab=_035_ }
C {sky130_stdcells/nand2_2.sym} 4980 40 0 0 {name=X_109_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 4940 170 0 0 {name=p156 lab=_035_ }
C {devices/lab_pin.sym} 5020 170 0 1 {name=p157 lab=_020_ }
C {sky130_stdcells/inv_2.sym} 4980 170 0 0 {name=X_110_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 4920 280 0 0 {name=p158 lab=clk_comp }
C {devices/lab_pin.sym} 4920 320 0 0 {name=p159 lab=_034_ }
C {devices/lab_pin.sym} 5040 300 0 1 {name=p160 lab=_036_ }
C {sky130_stdcells/nand2_2.sym} 4980 300 0 0 {name=X_111_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 4900 390 0 0 {name=p161 lab=_042_ }
C {devices/lab_pin.sym} 4900 430 0 0 {name=p162 lab=_020_ }
C {devices/lab_pin.sym} 4900 470 0 0 {name=p163 lab=_036_ }
C {devices/lab_pin.sym} 4900 510 0 0 {name=p164 lab=dac_ctrl[7] }
C {devices/lab_pin.sym} 4900 550 0 0 {name=p165 lab=sar__logic__0_deoc }
C {devices/lab_pin.sym} 5060 470 0 1 {name=p166 lab=_008_ }
C {sky130_stdcells/a221o_2.sym} 4980 470 0 0 {name=X_112_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 4920 620 0 0 {name=p167 lab=sar__logic__0_deoc }
C {devices/lab_pin.sym} 4920 660 0 0 {name=p168 lab=smp__clk__div__0_dstart }
C {devices/lab_pin.sym} 5040 640 0 1 {name=p169 lab=_037_ }
C {sky130_stdcells/nor2_2.sym} 4980 640 0 0 {name=X_113_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 4920 760 0 0 {name=p170 lab=_041_ }
C {devices/lab_pin.sym} 4920 800 0 0 {name=p171 lab=_037_ }
C {devices/lab_pin.sym} 5040 780 0 1 {name=p172 lab=_027_ }
C {sky130_stdcells/nor2_2.sym} 4980 780 0 0 {name=X_114_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 4920 900 0 0 {name=p173 lab=samp }
C {devices/lab_pin.sym} 4920 940 0 0 {name=p174 lab=_037_ }
C {devices/lab_pin.sym} 5040 920 0 1 {name=p175 lab=_038_ }
C {sky130_stdcells/nand2_2.sym} 4980 920 0 0 {name=X_115_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 4900 1010 0 0 {name=p176 lab=_043_ }
C {devices/lab_pin.sym} 4900 1050 0 0 {name=p177 lab=_047_ }
C {devices/lab_pin.sym} 4900 1090 0 0 {name=p178 lab=samp }
C {devices/lab_pin.sym} 4900 1130 0 0 {name=p179 lab=_038_ }
C {devices/lab_pin.sym} 4900 1170 0 0 {name=p180 lab=en }
C {devices/lab_pin.sym} 5060 1090 0 1 {name=p181 lab=_028_ }
C {sky130_stdcells/o311a_2.sym} 4980 1090 0 0 {name=X_116_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 4920 1230 0 0 {name=p182 lab=samp }
C {devices/lab_pin.sym} 4920 1270 0 0 {name=p183 lab=_037_ }
C {devices/lab_pin.sym} 4920 1310 0 0 {name=p184 lab=en }
C {devices/lab_pin.sym} 5040 1270 0 1 {name=p185 lab=_025_ }
C {sky130_stdcells/and3b_2.sym} 4980 1270 0 0 {name=X_117_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 4920 1400 0 0 {name=p186 lab=_041_ }
C {devices/lab_pin.sym} 4920 1440 0 0 {name=p187 lab=_038_ }
C {devices/lab_pin.sym} 5040 1420 0 1 {name=p188 lab=_026_ }
C {sky130_stdcells/nor2_2.sym} 4980 1420 0 0 {name=X_118_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 5840 10 0 0 {name=p189 lab=sar__logic__0_deoc }
C {devices/lab_pin.sym} 5840 50 0 0 {name=p190 lab=clk_comp }
C {devices/lab_pin.sym} 5840 90 0 0 {name=p191 lab=_053_ }
C {devices/lab_pin.sym} 5960 50 0 1 {name=p192 lab=_022_ }
C {sky130_stdcells/nor3_2.sym} 5900 50 0 0 {name=X_119_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 5820 170 0 0 {name=p193 lab=_051_ }
C {devices/lab_pin.sym} 5820 210 0 0 {name=p194 lab=_034_ }
C {devices/lab_pin.sym} 5820 250 0 0 {name=p195 lab=_041_ }
C {devices/lab_pin.sym} 5980 210 0 1 {name=p196 lab=_021_ }
C {sky130_stdcells/a21oi_2.sym} 5900 210 0 0 {name=X_120_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 5840 340 0 0 {name=p197 lab=_043_ }
C {devices/lab_pin.sym} 5840 380 0 0 {name=p198 lab=_021_ }
C {devices/lab_pin.sym} 5960 360 0 1 {name=p199 lab=_023_ }
C {sky130_stdcells/and2_2.sym} 5900 360 0 0 {name=X_121_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 5820 460 0 0 {name=p200 lab=_052_ }
C {devices/lab_pin.sym} 5820 500 0 0 {name=p201 lab=_034_ }
C {devices/lab_pin.sym} 5820 540 0 0 {name=p202 lab=en }
C {devices/lab_pin.sym} 5820 580 0 0 {name=p203 lab=_043_ }
C {devices/lab_pin.sym} 5980 520 0 1 {name=p204 lab=_024_ }
C {sky130_stdcells/o211a_2.sym} 5900 520 0 0 {name=X_122_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 5820 640 0 0 {name=p205 lab=dac_ctrl[0] }
C {devices/lab_pin.sym} 5820 680 0 0 {name=p206 lab=_035_ }
C {devices/lab_pin.sym} 5820 720 0 0 {name=p207 lab=_021_ }
C {devices/lab_pin.sym} 5820 760 0 0 {name=p208 lab=dout[0] }
C {devices/lab_pin.sym} 5980 700 0 1 {name=p209 lab=_012_ }
C {sky130_stdcells/a2bb2o_2.sym} 5900 700 0 0 {name=X_123_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 5820 820 0 0 {name=p210 lab=dac_ctrl[1] }
C {devices/lab_pin.sym} 5820 860 0 0 {name=p211 lab=_035_ }
C {devices/lab_pin.sym} 5820 900 0 0 {name=p212 lab=_021_ }
C {devices/lab_pin.sym} 5820 940 0 0 {name=p213 lab=dout[1] }
C {devices/lab_pin.sym} 5980 880 0 1 {name=p214 lab=_013_ }
C {sky130_stdcells/a2bb2o_2.sym} 5900 880 0 0 {name=X_124_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 5820 1000 0 0 {name=p215 lab=dac_ctrl[2] }
C {devices/lab_pin.sym} 5820 1040 0 0 {name=p216 lab=_035_ }
C {devices/lab_pin.sym} 5820 1080 0 0 {name=p217 lab=_021_ }
C {devices/lab_pin.sym} 5820 1120 0 0 {name=p218 lab=dout[2] }
C {devices/lab_pin.sym} 5980 1060 0 1 {name=p219 lab=_014_ }
C {sky130_stdcells/a2bb2o_2.sym} 5900 1060 0 0 {name=X_125_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 5820 1180 0 0 {name=p220 lab=dac_ctrl[3] }
C {devices/lab_pin.sym} 5820 1220 0 0 {name=p221 lab=_035_ }
C {devices/lab_pin.sym} 5820 1260 0 0 {name=p222 lab=_021_ }
C {devices/lab_pin.sym} 5820 1300 0 0 {name=p223 lab=dout[3] }
C {devices/lab_pin.sym} 5980 1240 0 1 {name=p224 lab=_015_ }
C {sky130_stdcells/a2bb2o_2.sym} 5900 1240 0 0 {name=X_126_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 5820 1360 0 0 {name=p225 lab=dac_ctrl[4] }
C {devices/lab_pin.sym} 5820 1400 0 0 {name=p226 lab=_035_ }
C {devices/lab_pin.sym} 5820 1440 0 0 {name=p227 lab=_021_ }
C {devices/lab_pin.sym} 5820 1480 0 0 {name=p228 lab=dout[4] }
C {devices/lab_pin.sym} 5980 1420 0 1 {name=p229 lab=_016_ }
C {sky130_stdcells/a2bb2o_2.sym} 5900 1420 0 0 {name=X_127_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 6740 0 0 0 {name=p230 lab=dac_ctrl[5] }
C {devices/lab_pin.sym} 6740 40 0 0 {name=p231 lab=_035_ }
C {devices/lab_pin.sym} 6740 80 0 0 {name=p232 lab=_021_ }
C {devices/lab_pin.sym} 6740 120 0 0 {name=p233 lab=dout[5] }
C {devices/lab_pin.sym} 6900 60 0 1 {name=p234 lab=_017_ }
C {sky130_stdcells/a2bb2o_2.sym} 6820 60 0 0 {name=X_128_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 6740 180 0 0 {name=p235 lab=dac_ctrl[6] }
C {devices/lab_pin.sym} 6740 220 0 0 {name=p236 lab=_035_ }
C {devices/lab_pin.sym} 6740 260 0 0 {name=p237 lab=_021_ }
C {devices/lab_pin.sym} 6740 300 0 0 {name=p238 lab=dout[6] }
C {devices/lab_pin.sym} 6900 240 0 1 {name=p239 lab=_018_ }
C {sky130_stdcells/a2bb2o_2.sym} 6820 240 0 0 {name=X_129_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 6740 360 0 0 {name=p240 lab=dac_ctrl[7] }
C {devices/lab_pin.sym} 6740 400 0 0 {name=p241 lab=_035_ }
C {devices/lab_pin.sym} 6740 440 0 0 {name=p242 lab=_021_ }
C {devices/lab_pin.sym} 6740 480 0 0 {name=p243 lab=dout[7] }
C {devices/lab_pin.sym} 6900 420 0 1 {name=p244 lab=_019_ }
C {sky130_stdcells/a2bb2o_2.sym} 6820 420 0 0 {name=X_130_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 6780 570 0 0 {name=p245 lab=_051_ }
C {devices/lab_pin.sym} 6780 610 0 0 {name=p246 lab=_024_ }
C {devices/lab_pin.sym} 6780 650 0 0 {name=p247 lab=sar__logic__0_dcount_o0_c }
C {devices/lab_pin.sym} 6860 590 0 1 {name=p248 lab=_009_ }
C {sky130_stdcells/mux2_1.sym} 6820 590 0 0 {name=X_131_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 6760 720 0 0 {name=p249 lab=_051_ }
C {devices/lab_pin.sym} 6760 760 0 0 {name=p250 lab=_063_ }
C {devices/lab_pin.sym} 6880 740 0 1 {name=p251 lab=_039_ }
C {sky130_stdcells/nand2_2.sym} 6820 740 0 0 {name=X_132_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 6740 840 0 0 {name=p252 lab=_049_ }
C {devices/lab_pin.sym} 6740 880 0 0 {name=p253 lab=_039_ }
C {devices/lab_pin.sym} 6740 920 0 0 {name=p254 lab=_024_ }
C {devices/lab_pin.sym} 6740 960 0 0 {name=p255 lab=sar__logic__0_dcount_o1_c }
C {devices/lab_pin.sym} 6900 900 0 1 {name=p256 lab=_010_ }
C {sky130_stdcells/a2bb2o_2.sym} 6820 900 0 0 {name=X_133_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 6740 1010 0 0 {name=p257 lab=_041_ }
C {devices/lab_pin.sym} 6740 1050 0 0 {name=p258 lab=sar__logic__0_deoc }
C {devices/lab_pin.sym} 6740 1090 0 0 {name=p259 lab=_048_ }
C {devices/lab_pin.sym} 6740 1130 0 0 {name=p260 lab=_052_ }
C {devices/lab_pin.sym} 6740 1170 0 0 {name=p261 lab=_034_ }
C {devices/lab_pin.sym} 6900 1090 0 1 {name=p262 lab=_040_ }
C {sky130_stdcells/o32a_2.sym} 6820 1090 0 0 {name=X_134_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 6740 1230 0 0 {name=p263 lab=_048_ }
C {devices/lab_pin.sym} 6740 1270 0 0 {name=p264 lab=_063_ }
C {devices/lab_pin.sym} 6740 1310 0 0 {name=p265 lab=_040_ }
C {devices/lab_pin.sym} 6900 1270 0 1 {name=p266 lab=_011_ }
C {sky130_stdcells/a21oi_2.sym} 6820 1270 0 0 {name=X_135_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 6760 1400 0 0 {name=p267 lab=clk_comp_shifted }
C {devices/lab_pin.sym} 6760 1440 0 0 {name=p268 lab=en }
C {devices/lab_pin.sym} 6880 1420 0 1 {name=p269 lab=_031_ }
C {sky130_stdcells/and2b_2.sym} 6820 1420 0 0 {name=X_136_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 7660 10 0 0 {name=p270 lab=vcp }
C {devices/lab_pin.sym} 7660 50 0 0 {name=p271 lab=_046_ }
C {devices/lab_pin.sym} 7660 90 0 0 {name=p272 lab=en }
C {devices/lab_pin.sym} 7820 50 0 1 {name=p273 lab=_032_ }
C {sky130_stdcells/o21a_2.sym} 7740 50 0 0 {name=X_137_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 7650 190 0 0 {name=p274 lab=_029_ }
C {devices/lab_pin.sym} 7650 210 0 0 {name=p275 lab=_030_ }
C {devices/lab_pin.sym} 7830 190 0 1 {name=p276 lab=clk_comp }
C {sky130_stdcells/dfxtp_2.sym} 7740 200 0 0 {name=X_138_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 7650 330 0 0 {name=p277 lab=clk }
C {devices/lab_pin.sym} 7650 350 0 0 {name=p278 lab=_031_ }
C {devices/lab_pin.sym} 7830 330 0 1 {name=p279 lab=clk_comp_shifted }
C {sky130_stdcells/dfxtp_2.sym} 7740 340 0 0 {name=X_139_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 7650 470 0 0 {name=p280 lab=_025_ }
C {devices/lab_pin.sym} 7650 490 0 0 {name=p281 lab=_027_ }
C {devices/lab_pin.sym} 7830 470 0 1 {name=p282 lab=samp }
C {sky130_stdcells/dlxtn_1.sym} 7740 480 0 0 {name=X_140_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 7650 610 0 0 {name=p283 lab=_026_ }
C {devices/lab_pin.sym} 7650 630 0 0 {name=p284 lab=_028_ }
C {devices/lab_pin.sym} 7830 610 0 1 {name=p285 lab=smp__clk__div__0_dstart }
C {sky130_stdcells/dlxtn_1.sym} 7740 620 0 0 {name=X_141_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 7650 750 0 0 {name=p286 lab=_000_ }
C {devices/lab_pin.sym} 7650 770 0 0 {name=p287 lab=_032_ }
C {devices/lab_pin.sym} 7830 750 0 1 {name=p288 lab=cmp__processor__0_dcomp }
C {sky130_stdcells/dfxtp_2.sym} 7740 760 0 0 {name=X_142_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 7650 890 0 0 {name=p289 lab=_001_ }
C {devices/lab_pin.sym} 7650 910 0 0 {name=p290 lab=_022_ }
C {devices/lab_pin.sym} 7830 890 0 1 {name=p291 lab=dac_ctrl[0] }
C {sky130_stdcells/dlxtn_1.sym} 7740 900 0 0 {name=X_143_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 7650 1030 0 0 {name=p292 lab=_002_ }
C {devices/lab_pin.sym} 7650 1050 0 0 {name=p293 lab=_022_ }
C {devices/lab_pin.sym} 7830 1030 0 1 {name=p294 lab=dac_ctrl[1] }
C {sky130_stdcells/dlxtn_1.sym} 7740 1040 0 0 {name=X_144_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 7650 1170 0 0 {name=p295 lab=_003_ }
C {devices/lab_pin.sym} 7650 1190 0 0 {name=p296 lab=_022_ }
C {devices/lab_pin.sym} 7830 1170 0 1 {name=p297 lab=dac_ctrl[2] }
C {sky130_stdcells/dlxtn_1.sym} 7740 1180 0 0 {name=X_145_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 7650 1310 0 0 {name=p298 lab=_004_ }
C {devices/lab_pin.sym} 7650 1330 0 0 {name=p299 lab=_022_ }
C {devices/lab_pin.sym} 7830 1310 0 1 {name=p300 lab=dac_ctrl[3] }
C {sky130_stdcells/dlxtn_1.sym} 7740 1320 0 0 {name=X_146_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 7650 1450 0 0 {name=p301 lab=_005_ }
C {devices/lab_pin.sym} 7650 1470 0 0 {name=p302 lab=_022_ }
C {devices/lab_pin.sym} 7830 1450 0 1 {name=p303 lab=dac_ctrl[4] }
C {sky130_stdcells/dlxtn_1.sym} 7740 1460 0 0 {name=X_147_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 8570 30 0 0 {name=p304 lab=_006_ }
C {devices/lab_pin.sym} 8570 50 0 0 {name=p305 lab=_022_ }
C {devices/lab_pin.sym} 8750 30 0 1 {name=p306 lab=dac_ctrl[5] }
C {sky130_stdcells/dlxtn_1.sym} 8660 40 0 0 {name=X_148_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 8570 170 0 0 {name=p307 lab=_007_ }
C {devices/lab_pin.sym} 8570 190 0 0 {name=p308 lab=_022_ }
C {devices/lab_pin.sym} 8750 170 0 1 {name=p309 lab=dac_ctrl[6] }
C {sky130_stdcells/dlxtn_1.sym} 8660 180 0 0 {name=X_149_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 8570 310 0 0 {name=p310 lab=_008_ }
C {devices/lab_pin.sym} 8570 330 0 0 {name=p311 lab=_022_ }
C {devices/lab_pin.sym} 8750 310 0 1 {name=p312 lab=dac_ctrl[7] }
C {sky130_stdcells/dlxtn_1.sym} 8660 320 0 0 {name=X_150_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 8570 450 0 0 {name=p313 lab=_012_ }
C {devices/lab_pin.sym} 8570 470 0 0 {name=p314 lab=_021_ }
C {devices/lab_pin.sym} 8750 450 0 1 {name=p315 lab=dout[0] }
C {sky130_stdcells/dlxtn_1.sym} 8660 460 0 0 {name=X_151_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 8570 590 0 0 {name=p316 lab=_013_ }
C {devices/lab_pin.sym} 8570 610 0 0 {name=p317 lab=_021_ }
C {devices/lab_pin.sym} 8750 590 0 1 {name=p318 lab=dout[1] }
C {sky130_stdcells/dlxtn_1.sym} 8660 600 0 0 {name=X_152_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 8570 730 0 0 {name=p319 lab=_014_ }
C {devices/lab_pin.sym} 8570 750 0 0 {name=p320 lab=_021_ }
C {devices/lab_pin.sym} 8750 730 0 1 {name=p321 lab=dout[2] }
C {sky130_stdcells/dlxtn_1.sym} 8660 740 0 0 {name=X_153_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 8570 870 0 0 {name=p322 lab=_015_ }
C {devices/lab_pin.sym} 8570 890 0 0 {name=p323 lab=_021_ }
C {devices/lab_pin.sym} 8750 870 0 1 {name=p324 lab=dout[3] }
C {sky130_stdcells/dlxtn_1.sym} 8660 880 0 0 {name=X_154_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 8570 1010 0 0 {name=p325 lab=_016_ }
C {devices/lab_pin.sym} 8570 1030 0 0 {name=p326 lab=_021_ }
C {devices/lab_pin.sym} 8750 1010 0 1 {name=p327 lab=dout[4] }
C {sky130_stdcells/dlxtn_1.sym} 8660 1020 0 0 {name=X_155_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 8570 1150 0 0 {name=p328 lab=_017_ }
C {devices/lab_pin.sym} 8570 1170 0 0 {name=p329 lab=_021_ }
C {devices/lab_pin.sym} 8750 1150 0 1 {name=p330 lab=dout[5] }
C {sky130_stdcells/dlxtn_1.sym} 8660 1160 0 0 {name=X_156_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 8570 1290 0 0 {name=p331 lab=_018_ }
C {devices/lab_pin.sym} 8570 1310 0 0 {name=p332 lab=_021_ }
C {devices/lab_pin.sym} 8750 1290 0 1 {name=p333 lab=dout[6] }
C {sky130_stdcells/dlxtn_1.sym} 8660 1300 0 0 {name=X_157_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 8570 1430 0 0 {name=p334 lab=_019_ }
C {devices/lab_pin.sym} 8570 1450 0 0 {name=p335 lab=_021_ }
C {devices/lab_pin.sym} 8750 1430 0 1 {name=p336 lab=dout[7] }
C {sky130_stdcells/dlxtn_1.sym} 8660 1440 0 0 {name=X_158_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 9490 30 0 0 {name=p337 lab=_020_ }
C {devices/lab_pin.sym} 9490 50 0 0 {name=p338 lab=_023_ }
C {devices/lab_pin.sym} 9670 30 0 1 {name=p339 lab=sar__logic__0_deoc }
C {sky130_stdcells/dlxtn_1.sym} 9580 40 0 0 {name=X_159_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 9490 170 0 0 {name=p340 lab=_009_ }
C {devices/lab_pin.sym} 9490 190 0 0 {name=p341 lab=_024_ }
C {devices/lab_pin.sym} 9670 170 0 1 {name=p342 lab=sar__logic__0_dcount_o0_c }
C {sky130_stdcells/dlxtn_1.sym} 9580 180 0 0 {name=X_160_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 9490 310 0 0 {name=p343 lab=_010_ }
C {devices/lab_pin.sym} 9490 330 0 0 {name=p344 lab=_024_ }
C {devices/lab_pin.sym} 9670 310 0 1 {name=p345 lab=sar__logic__0_dcount_o1_c }
C {sky130_stdcells/dlxtn_1.sym} 9580 320 0 0 {name=X_161_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/lab_pin.sym} 9490 450 0 0 {name=p346 lab=_011_ }
C {devices/lab_pin.sym} 9490 470 0 0 {name=p347 lab=_024_ }
C {devices/lab_pin.sym} 9670 450 0 1 {name=p348 lab=sar__logic__0_dcount_o2_c }
C {sky130_stdcells/dlxtn_1.sym} 9580 460 0 0 {name=X_162_ VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 9580 620 0 0 {name=XPHY_EDGE_ROW_0_Right_0 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 9580 800 0 0 {name=XPHY_EDGE_ROW_1_Right_1 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 9580 980 0 0 {name=XPHY_EDGE_ROW_2_Right_2 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 9580 1160 0 0 {name=XPHY_EDGE_ROW_3_Right_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 9580 1340 0 0 {name=XPHY_EDGE_ROW_4_Right_4 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 9580 1520 0 0 {name=XPHY_EDGE_ROW_5_Right_5 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 10500 60 0 0 {name=XPHY_EDGE_ROW_6_Right_6 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 10500 240 0 0 {name=XPHY_EDGE_ROW_7_Right_7 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 10500 420 0 0 {name=XPHY_EDGE_ROW_8_Right_8 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 10500 600 0 0 {name=XPHY_EDGE_ROW_9_Right_9 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 10500 780 0 0 {name=XPHY_EDGE_ROW_10_Right_10 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 10500 960 0 0 {name=XPHY_EDGE_ROW_11_Right_11 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 10500 1140 0 0 {name=XPHY_EDGE_ROW_12_Right_12 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 10500 1320 0 0 {name=XPHY_EDGE_ROW_13_Right_13 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 10500 1500 0 0 {name=XPHY_EDGE_ROW_14_Right_14 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 11420 60 0 0 {name=XPHY_EDGE_ROW_15_Right_15 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 11420 240 0 0 {name=XPHY_EDGE_ROW_16_Right_16 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 11420 420 0 0 {name=XPHY_EDGE_ROW_17_Right_17 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 11420 600 0 0 {name=XPHY_EDGE_ROW_18_Right_18 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 11420 780 0 0 {name=XPHY_EDGE_ROW_19_Right_19 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 11420 960 0 0 {name=XPHY_EDGE_ROW_20_Right_20 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 11420 1140 0 0 {name=XPHY_EDGE_ROW_21_Right_21 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 11420 1320 0 0 {name=XPHY_EDGE_ROW_22_Right_22 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 11420 1500 0 0 {name=XPHY_EDGE_ROW_23_Right_23 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 12340 60 0 0 {name=XPHY_EDGE_ROW_24_Right_24 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 12340 240 0 0 {name=XPHY_EDGE_ROW_0_Left_25 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 12340 420 0 0 {name=XPHY_EDGE_ROW_1_Left_26 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 12340 600 0 0 {name=XPHY_EDGE_ROW_2_Left_27 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 12340 780 0 0 {name=XPHY_EDGE_ROW_3_Left_28 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 12340 960 0 0 {name=XPHY_EDGE_ROW_4_Left_29 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 12340 1140 0 0 {name=XPHY_EDGE_ROW_5_Left_30 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 12340 1320 0 0 {name=XPHY_EDGE_ROW_6_Left_31 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 12340 1500 0 0 {name=XPHY_EDGE_ROW_7_Left_32 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 13260 60 0 0 {name=XPHY_EDGE_ROW_8_Left_33 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 13260 240 0 0 {name=XPHY_EDGE_ROW_9_Left_34 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 13260 420 0 0 {name=XPHY_EDGE_ROW_10_Left_35 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 13260 600 0 0 {name=XPHY_EDGE_ROW_11_Left_36 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 13260 780 0 0 {name=XPHY_EDGE_ROW_12_Left_37 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 13260 960 0 0 {name=XPHY_EDGE_ROW_13_Left_38 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 13260 1140 0 0 {name=XPHY_EDGE_ROW_14_Left_39 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 13260 1320 0 0 {name=XPHY_EDGE_ROW_15_Left_40 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 13260 1500 0 0 {name=XPHY_EDGE_ROW_16_Left_41 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 14180 60 0 0 {name=XPHY_EDGE_ROW_17_Left_42 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 14180 240 0 0 {name=XPHY_EDGE_ROW_18_Left_43 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 14180 420 0 0 {name=XPHY_EDGE_ROW_19_Left_44 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 14180 600 0 0 {name=XPHY_EDGE_ROW_20_Left_45 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 14180 780 0 0 {name=XPHY_EDGE_ROW_21_Left_46 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 14180 960 0 0 {name=XPHY_EDGE_ROW_22_Left_47 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 14180 1140 0 0 {name=XPHY_EDGE_ROW_23_Left_48 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 14180 1320 0 0 {name=XPHY_EDGE_ROW_24_Left_49 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 14180 1500 0 0 {name=XTAP_TAPCELL_ROW_0_50 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 15100 60 0 0 {name=XTAP_TAPCELL_ROW_0_51 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 15100 240 0 0 {name=XTAP_TAPCELL_ROW_0_52 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 15100 420 0 0 {name=XTAP_TAPCELL_ROW_0_53 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 15100 600 0 0 {name=XTAP_TAPCELL_ROW_0_54 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 15100 780 0 0 {name=XTAP_TAPCELL_ROW_1_55 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 15100 960 0 0 {name=XTAP_TAPCELL_ROW_1_56 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 15100 1140 0 0 {name=XTAP_TAPCELL_ROW_2_57 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 15100 1320 0 0 {name=XTAP_TAPCELL_ROW_2_58 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 15100 1500 0 0 {name=XTAP_TAPCELL_ROW_2_59 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16020 60 0 0 {name=XTAP_TAPCELL_ROW_3_60 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16020 240 0 0 {name=XTAP_TAPCELL_ROW_3_61 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16020 420 0 0 {name=XTAP_TAPCELL_ROW_4_62 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16020 600 0 0 {name=XTAP_TAPCELL_ROW_4_63 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16020 780 0 0 {name=XTAP_TAPCELL_ROW_4_64 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16020 960 0 0 {name=XTAP_TAPCELL_ROW_5_65 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16020 1140 0 0 {name=XTAP_TAPCELL_ROW_5_66 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16020 1320 0 0 {name=XTAP_TAPCELL_ROW_6_67 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16020 1500 0 0 {name=XTAP_TAPCELL_ROW_6_68 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16940 60 0 0 {name=XTAP_TAPCELL_ROW_6_69 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16940 240 0 0 {name=XTAP_TAPCELL_ROW_7_70 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16940 420 0 0 {name=XTAP_TAPCELL_ROW_7_71 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16940 600 0 0 {name=XTAP_TAPCELL_ROW_8_72 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16940 780 0 0 {name=XTAP_TAPCELL_ROW_8_73 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16940 960 0 0 {name=XTAP_TAPCELL_ROW_8_74 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16940 1140 0 0 {name=XTAP_TAPCELL_ROW_9_75 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16940 1320 0 0 {name=XTAP_TAPCELL_ROW_9_76 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 16940 1500 0 0 {name=XTAP_TAPCELL_ROW_10_77 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 17860 60 0 0 {name=XTAP_TAPCELL_ROW_10_78 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 17860 240 0 0 {name=XTAP_TAPCELL_ROW_10_79 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 17860 420 0 0 {name=XTAP_TAPCELL_ROW_11_80 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 17860 600 0 0 {name=XTAP_TAPCELL_ROW_11_81 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 17860 780 0 0 {name=XTAP_TAPCELL_ROW_12_82 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 17860 960 0 0 {name=XTAP_TAPCELL_ROW_12_83 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 17860 1140 0 0 {name=XTAP_TAPCELL_ROW_12_84 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 17860 1320 0 0 {name=XTAP_TAPCELL_ROW_13_85 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 17860 1500 0 0 {name=XTAP_TAPCELL_ROW_13_86 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 18780 60 0 0 {name=XTAP_TAPCELL_ROW_14_87 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 18780 240 0 0 {name=XTAP_TAPCELL_ROW_14_88 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 18780 420 0 0 {name=XTAP_TAPCELL_ROW_14_89 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 18780 600 0 0 {name=XTAP_TAPCELL_ROW_15_90 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 18780 780 0 0 {name=XTAP_TAPCELL_ROW_15_91 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 18780 960 0 0 {name=XTAP_TAPCELL_ROW_16_92 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 18780 1140 0 0 {name=XTAP_TAPCELL_ROW_16_93 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 18780 1320 0 0 {name=XTAP_TAPCELL_ROW_16_94 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 18780 1500 0 0 {name=XTAP_TAPCELL_ROW_17_95 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 19700 60 0 0 {name=XTAP_TAPCELL_ROW_17_96 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 19700 240 0 0 {name=XTAP_TAPCELL_ROW_18_97 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 19700 420 0 0 {name=XTAP_TAPCELL_ROW_18_98 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 19700 600 0 0 {name=XTAP_TAPCELL_ROW_18_99 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 19700 780 0 0 {name=XTAP_TAPCELL_ROW_19_100 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 19700 960 0 0 {name=XTAP_TAPCELL_ROW_19_101 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 19700 1140 0 0 {name=XTAP_TAPCELL_ROW_20_102 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 19700 1320 0 0 {name=XTAP_TAPCELL_ROW_20_103 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 19700 1500 0 0 {name=XTAP_TAPCELL_ROW_20_104 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 20620 60 0 0 {name=XTAP_TAPCELL_ROW_21_105 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 20620 240 0 0 {name=XTAP_TAPCELL_ROW_21_106 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 20620 420 0 0 {name=XTAP_TAPCELL_ROW_22_107 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 20620 600 0 0 {name=XTAP_TAPCELL_ROW_22_108 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 20620 780 0 0 {name=XTAP_TAPCELL_ROW_22_109 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 20620 960 0 0 {name=XTAP_TAPCELL_ROW_23_110 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 20620 1140 0 0 {name=XTAP_TAPCELL_ROW_23_111 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 20620 1320 0 0 {name=XTAP_TAPCELL_ROW_24_112 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 20620 1500 0 0 {name=XTAP_TAPCELL_ROW_24_113 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 21540 60 0 0 {name=XTAP_TAPCELL_ROW_24_114 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 21540 240 0 0 {name=XTAP_TAPCELL_ROW_24_115 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/tapvpwrvgnd_1.sym} 21540 420 0 0 {name=XTAP_TAPCELL_ROW_24_116 VGND=VGND VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 21540 600 0 0 {name=XFILLER_0_0_27 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 21540 780 0 0 {name=XFILLER_0_0_53 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 21540 960 0 0 {name=XFILLER_0_0_81 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 21540 1140 0 0 {name=XFILLER_0_0_109 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 21540 1320 0 0 {name=XFILLER_0_0_137 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 21540 1500 0 0 {name=XFILLER_0_0_141 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 22460 60 0 0 {name=XFILLER_0_0_147 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 22460 240 0 0 {name=XFILLER_0_1_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_4.sym} 22460 420 0 0 {name=XFILLER_0_1_33 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 22460 600 0 0 {name=XFILLER_0_1_49 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 22460 780 0 0 {name=XFILLER_0_1_55 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 22460 960 0 0 {name=XFILLER_0_1_105 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 22460 1140 0 0 {name=XFILLER_0_1_111 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 22460 1320 0 0 {name=XFILLER_0_1_137 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 22460 1500 0 0 {name=XFILLER_0_1_145 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 23380 60 0 0 {name=XFILLER_0_2_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 23380 240 0 0 {name=XFILLER_0_2_21 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 23380 420 0 0 {name=XFILLER_0_2_27 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 23380 600 0 0 {name=XFILLER_0_2_41 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 23380 780 0 0 {name=XFILLER_0_2_55 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 23380 960 0 0 {name=XFILLER_0_2_77 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 23380 1140 0 0 {name=XFILLER_0_2_83 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 23380 1320 0 0 {name=XFILLER_0_2_133 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 23380 1500 0 0 {name=XFILLER_0_2_139 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 24300 60 0 0 {name=XFILLER_0_2_141 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 24300 240 0 0 {name=XFILLER_0_2_147 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 24300 420 0 0 {name=XFILLER_0_3_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 24300 600 0 0 {name=XFILLER_0_3_41 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 24300 780 0 0 {name=XFILLER_0_3_57 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 24300 960 0 0 {name=XFILLER_0_3_82 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 24300 1140 0 0 {name=XFILLER_0_3_102 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 24300 1320 0 0 {name=XFILLER_0_3_110 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 24300 1500 0 0 {name=XFILLER_0_3_137 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 25220 60 0 0 {name=XFILLER_0_3_145 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 25220 240 0 0 {name=XFILLER_0_4_27 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_4.sym} 25220 420 0 0 {name=XFILLER_0_4_53 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 25220 600 0 0 {name=XFILLER_0_4_57 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 25220 780 0 0 {name=XFILLER_0_4_75 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 25220 960 0 0 {name=XFILLER_0_4_81 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_4.sym} 25220 1140 0 0 {name=XFILLER_0_4_85 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 25220 1320 0 0 {name=XFILLER_0_4_89 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_4.sym} 25220 1500 0 0 {name=XFILLER_0_4_96 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 26140 60 0 0 {name=XFILLER_0_4_100 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 26140 240 0 0 {name=XFILLER_0_4_130 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 26140 420 0 0 {name=XFILLER_0_4_138 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 26140 600 0 0 {name=XFILLER_0_4_141 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 26140 780 0 0 {name=XFILLER_0_4_147 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 26140 960 0 0 {name=XFILLER_0_5_27 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 26140 1140 0 0 {name=XFILLER_0_5_35 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 26140 1320 0 0 {name=XFILLER_0_5_50 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 26140 1500 0 0 {name=XFILLER_0_5_102 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 27060 60 0 0 {name=XFILLER_0_5_110 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 27060 240 0 0 {name=XFILLER_0_5_137 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 27060 420 0 0 {name=XFILLER_0_5_145 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 27060 600 0 0 {name=XFILLER_0_6_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_4.sym} 27060 780 0 0 {name=XFILLER_0_6_24 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 27060 960 0 0 {name=XFILLER_0_6_77 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 27060 1140 0 0 {name=XFILLER_0_6_83 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 27060 1320 0 0 {name=XFILLER_0_6_133 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 27060 1500 0 0 {name=XFILLER_0_6_139 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 27980 60 0 0 {name=XFILLER_0_6_141 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 27980 240 0 0 {name=XFILLER_0_6_147 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 27980 420 0 0 {name=XFILLER_0_7_48 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_4.sym} 27980 600 0 0 {name=XFILLER_0_7_57 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 27980 780 0 0 {name=XFILLER_0_7_83 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 27980 960 0 0 {name=XFILLER_0_7_101 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 27980 1140 0 0 {name=XFILLER_0_7_109 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 27980 1320 0 0 {name=XFILLER_0_7_137 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 27980 1500 0 0 {name=XFILLER_0_7_145 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 28900 60 0 0 {name=XFILLER_0_8_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 28900 240 0 0 {name=XFILLER_0_8_11 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_4.sym} 28900 420 0 0 {name=XFILLER_0_8_23 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 28900 600 0 0 {name=XFILLER_0_8_27 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 28900 780 0 0 {name=XFILLER_0_8_58 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 28900 960 0 0 {name=XFILLER_0_8_82 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 28900 1140 0 0 {name=XFILLER_0_8_85 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 28900 1320 0 0 {name=XFILLER_0_8_141 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 28900 1500 0 0 {name=XFILLER_0_8_147 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 29820 60 0 0 {name=XFILLER_0_9_39 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 29820 240 0 0 {name=XFILLER_0_9_53 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 29820 420 0 0 {name=XFILLER_0_9_66 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 29820 600 0 0 {name=XFILLER_0_9_87 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 29820 780 0 0 {name=XFILLER_0_9_105 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 29820 960 0 0 {name=XFILLER_0_9_111 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 29820 1140 0 0 {name=XFILLER_0_9_137 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 29820 1320 0 0 {name=XFILLER_0_9_145 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 29820 1500 0 0 {name=XFILLER_0_10_27 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 30740 60 0 0 {name=XFILLER_0_10_41 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 30740 240 0 0 {name=XFILLER_0_10_49 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 30740 420 0 0 {name=XFILLER_0_10_82 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 30740 600 0 0 {name=XFILLER_0_10_133 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 30740 780 0 0 {name=XFILLER_0_10_139 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 30740 960 0 0 {name=XFILLER_0_10_141 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 30740 1140 0 0 {name=XFILLER_0_10_147 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 30740 1320 0 0 {name=XFILLER_0_11_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 30740 1500 0 0 {name=XFILLER_0_11_11 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_4.sym} 31660 60 0 0 {name=XFILLER_0_11_51 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 31660 240 0 0 {name=XFILLER_0_11_55 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 31660 420 0 0 {name=XFILLER_0_11_81 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 31660 600 0 0 {name=XFILLER_0_11_89 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 31660 780 0 0 {name=XFILLER_0_11_100 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 31660 960 0 0 {name=XFILLER_0_11_106 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 31660 1140 0 0 {name=XFILLER_0_11_137 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 31660 1320 0 0 {name=XFILLER_0_11_145 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 31660 1500 0 0 {name=XFILLER_0_12_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 32580 60 0 0 {name=XFILLER_0_12_77 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 32580 240 0 0 {name=XFILLER_0_12_83 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 32580 420 0 0 {name=XFILLER_0_12_85 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 32580 600 0 0 {name=XFILLER_0_12_96 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 32580 780 0 0 {name=XFILLER_0_12_131 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 32580 960 0 0 {name=XFILLER_0_12_139 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 32580 1140 0 0 {name=XFILLER_0_12_141 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 32580 1320 0 0 {name=XFILLER_0_12_147 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 32580 1500 0 0 {name=XFILLER_0_13_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 33500 60 0 0 {name=XFILLER_0_13_40 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 33500 240 0 0 {name=XFILLER_0_13_64 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 33500 420 0 0 {name=XFILLER_0_13_85 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_4.sym} 33500 600 0 0 {name=XFILLER_0_13_98 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 33500 780 0 0 {name=XFILLER_0_13_102 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_4.sym} 33500 960 0 0 {name=XFILLER_0_13_108 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 33500 1140 0 0 {name=XFILLER_0_13_137 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 33500 1320 0 0 {name=XFILLER_0_13_145 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 33500 1500 0 0 {name=XFILLER_0_14_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 34420 60 0 0 {name=XFILLER_0_14_9 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 34420 240 0 0 {name=XFILLER_0_14_22 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 34420 420 0 0 {name=XFILLER_0_14_48 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 34420 600 0 0 {name=XFILLER_0_14_74 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 34420 780 0 0 {name=XFILLER_0_14_82 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 34420 960 0 0 {name=XFILLER_0_14_85 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_4.sym} 34420 1140 0 0 {name=XFILLER_0_14_93 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 34420 1320 0 0 {name=XFILLER_0_14_130 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 34420 1500 0 0 {name=XFILLER_0_14_138 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 35340 60 0 0 {name=XFILLER_0_14_141 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 35340 240 0 0 {name=XFILLER_0_14_147 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 35340 420 0 0 {name=XFILLER_0_15_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 35340 600 0 0 {name=XFILLER_0_15_9 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 35340 780 0 0 {name=XFILLER_0_15_29 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 35340 960 0 0 {name=XFILLER_0_15_48 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 35340 1140 0 0 {name=XFILLER_0_15_57 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 35340 1320 0 0 {name=XFILLER_0_15_111 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 35340 1500 0 0 {name=XFILLER_0_15_137 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 36260 60 0 0 {name=XFILLER_0_15_145 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 36260 240 0 0 {name=XFILLER_0_16_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 36260 420 0 0 {name=XFILLER_0_16_20 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 36260 600 0 0 {name=XFILLER_0_16_65 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 36260 780 0 0 {name=XFILLER_0_16_78 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 36260 960 0 0 {name=XFILLER_0_16_133 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 36260 1140 0 0 {name=XFILLER_0_16_139 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 36260 1320 0 0 {name=XFILLER_0_16_141 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 36260 1500 0 0 {name=XFILLER_0_16_147 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 37180 60 0 0 {name=XFILLER_0_17_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 37180 240 0 0 {name=XFILLER_0_17_45 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 37180 420 0 0 {name=XFILLER_0_17_53 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 37180 600 0 0 {name=XFILLER_0_17_81 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 37180 780 0 0 {name=XFILLER_0_17_87 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 37180 960 0 0 {name=XFILLER_0_17_137 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 37180 1140 0 0 {name=XFILLER_0_17_145 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 37180 1320 0 0 {name=XFILLER_0_18_27 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 37180 1500 0 0 {name=XFILLER_0_18_77 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 38100 60 0 0 {name=XFILLER_0_18_83 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 38100 240 0 0 {name=XFILLER_0_18_130 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 38100 420 0 0 {name=XFILLER_0_18_138 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 38100 600 0 0 {name=XFILLER_0_18_141 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 38100 780 0 0 {name=XFILLER_0_18_147 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 38100 960 0 0 {name=XFILLER_0_19_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 38100 1140 0 0 {name=XFILLER_0_19_11 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 38100 1320 0 0 {name=XFILLER_0_19_47 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 38100 1500 0 0 {name=XFILLER_0_19_55 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 39020 60 0 0 {name=XFILLER_0_19_72 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 39020 240 0 0 {name=XFILLER_0_19_76 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 39020 420 0 0 {name=XFILLER_0_19_106 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 39020 600 0 0 {name=XFILLER_0_19_137 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 39020 780 0 0 {name=XFILLER_0_19_145 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 39020 960 0 0 {name=XFILLER_0_20_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 39020 1140 0 0 {name=XFILLER_0_20_11 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_4.sym} 39020 1320 0 0 {name=XFILLER_0_20_24 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 39020 1500 0 0 {name=XFILLER_0_20_41 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 39940 60 0 0 {name=XFILLER_0_20_60 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_4.sym} 39940 240 0 0 {name=XFILLER_0_20_79 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 39940 420 0 0 {name=XFILLER_0_20_83 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 39940 600 0 0 {name=XFILLER_0_20_133 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 39940 780 0 0 {name=XFILLER_0_20_139 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 39940 960 0 0 {name=XFILLER_0_20_141 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 39940 1140 0 0 {name=XFILLER_0_20_147 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 39940 1320 0 0 {name=XFILLER_0_21_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 39940 1500 0 0 {name=XFILLER_0_21_11 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 40860 60 0 0 {name=XFILLER_0_21_33 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 40860 240 0 0 {name=XFILLER_0_21_41 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 40860 420 0 0 {name=XFILLER_0_21_110 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 40860 600 0 0 {name=XFILLER_0_21_137 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 40860 780 0 0 {name=XFILLER_0_21_145 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 40860 960 0 0 {name=XFILLER_0_22_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 40860 1140 0 0 {name=XFILLER_0_22_11 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_4.sym} 40860 1320 0 0 {name=XFILLER_0_22_24 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_4.sym} 40860 1500 0 0 {name=XFILLER_0_22_41 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 41780 60 0 0 {name=XFILLER_0_22_77 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 41780 240 0 0 {name=XFILLER_0_22_83 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 41780 420 0 0 {name=XFILLER_0_22_133 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 41780 600 0 0 {name=XFILLER_0_22_139 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 41780 780 0 0 {name=XFILLER_0_22_141 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 41780 960 0 0 {name=XFILLER_0_22_147 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 41780 1140 0 0 {name=XFILLER_0_23_3 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 41780 1320 0 0 {name=XFILLER_0_23_11 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 41780 1500 0 0 {name=XFILLER_0_23_47 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 42700 60 0 0 {name=XFILLER_0_23_55 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_2.sym} 42700 240 0 0 {name=XFILLER_0_23_110 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_8.sym} 42700 420 0 0 {name=XFILLER_0_23_137 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 42700 600 0 0 {name=XFILLER_0_23_145 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 42700 780 0 0 {name=XFILLER_0_24_27 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 42700 960 0 0 {name=XFILLER_0_24_53 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 42700 1140 0 0 {name=XFILLER_0_24_81 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 42700 1320 0 0 {name=XFILLER_0_24_109 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_3.sym} 42700 1500 0 0 {name=XFILLER_0_24_137 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/decap_6.sym} 43620 60 0 0 {name=XFILLER_0_24_141 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {sky130_stdcells/fill_1.sym} 43620 240 0 0 {name=XFILLER_0_24_147 VGND=VGND VNB=VGND VPB=VPWR VPWR=VPWR }
C {devices/ipin.sym} 190 110 0 0 {name=p360 lab=VPWR }
C {devices/ipin.sym} 190 130 0 0 {name=p361 lab=VGND }
